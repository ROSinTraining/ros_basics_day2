Commit message: day 2 update

File: myfirst_urdf/urdf/robot_add_dimention.urdf (robot description, URDF)
Before this commit: robot custum_robot, 3 links, 2 joints
Joints:
- joint base_joint: axis (none) -> 1 0 0
- joint joint1: axis (none) -> 1 0 0
